# Keil uVision project slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F02E STC
  cpu: IRAM(0-0xFF) IROM(0-0x7FF) CLOCK(45000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c SoftReset.c UseCommunication.c UseFlash.c
